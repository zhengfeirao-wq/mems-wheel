# Keil uVision project Tactile500.uvprojx, settings and files
target Tactile500_Right_Palm32_Short (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F402RB Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.7
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: Tactile500_Right_Palm32_Short +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_DAL_DRIVER,APM32F402xx,TACTILE_PROFILE=6
  c include: ..\..\Include;..\..\Config\Include;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include;..\..\..\..\Libraries\APM32F4xx_DAL_Driver\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../Source/: system_apm32f4xx.c
    ./: startup_apm32f402xx.s
  group DAL
    ../../../../Libraries/APM32F4xx_DAL_Driver/Source/: apm32f4xx_dal.c apm32f4xx_dal_cortex.c apm32f4xx_dal_dma.c apm32f4xx_dal_dma_ex.c apm32f4xx_dal_flash.c apm32f4xx_dal_flash_ex.c apm32f4xx_dal_gpio.c apm32f4xx_dal_pmu.c apm32f4xx_dal_pmu_ex.c apm32f4xx_dal_rcm.c apm32f4xx_dal_rcm_ex.c apm32f4xx_dal_spi.c apm32f4xx_dal_uart.c
  group Board configuration
    ../../Config/Source/: apm32f4xx_device_cfg.c apm32f4xx_gpio_cfg.c apm32f4xx_nvic_cfg.c apm32f4xx_rcm_cfg.c apm32f4xx_spi_cfg.c apm32f4xx_usart_cfg.c
  group Tactile500
    ../../Source/: main.c apm32f4xx_int.c tactile_protocol.c tactile_stream.c tactile_time.c tactile_sensor.c tactile_channels.c
target Tactile500_Left_Fingers12 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F402RB Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.7
  cpu: as above
  output: Tactile500_Left_Fingers12 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_DAL_DRIVER,APM32F402xx,TACTILE_PROFILE=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Tactile500_Right_Fingers12 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F402RB Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.7
  cpu: as above
  output: Tactile500_Right_Fingers12 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_DAL_DRIVER,APM32F402xx,TACTILE_PROFILE=2
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Tactile500_Left_Palm32_Long (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F402RB Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.7
  cpu: as above
  output: Tactile500_Left_Palm32_Long +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_DAL_DRIVER,APM32F402xx,TACTILE_PROFILE=3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Tactile500_Right_Palm32_Long (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F402RB Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.7
  cpu: as above
  output: Tactile500_Right_Palm32_Long +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_DAL_DRIVER,APM32F402xx,TACTILE_PROFILE=4
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Tactile500_Left_Palm32_Short (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F402RB Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.7
  cpu: as above
  output: Tactile500_Left_Palm32_Short +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_DAL_DRIVER,APM32F402xx,TACTILE_PROFILE=5
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
